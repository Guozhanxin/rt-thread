# Keil uVision project project.uvproj, settings and files
target rt-thread (ARM-ADS)
  device: STM32F407ZG STMicroelectronics
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x10000000-0x1000FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(25000000) CPUTYPE("Cortex-M4") FPU2
  output: rtthread
  AfterMake: fromelf --bin !L --output rtthread.bin
  c flags: Optim=1 OneElfS=1 uC99=1
  c define: USE_HAL_DRIVER, STM32F469xx, RT_USING_ARM_LIBC, __RTTHREAD__, __CLK_TCK=RT_TICK_PER_SECOND
  c include: applications;..\..\..\libcpu\arm\common;..\..\..\libcpu\arm\cortex-m4;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;..\..\..\components\drivers\include;board;board\CubeMX_Config\Inc;board\ports;..\libraries\HAL_Drivers;..\libraries\HAL_Drivers\config;..\..\..\components\dfs\include;..\..\..\components\dfs\filesystems\devfs;..\..\..\components\dfs\filesystems\elmfat;..\..\..\components\finsh;packages\gui_engine-latest\example;packages\gui_engine-latest\include;packages\gui_engine-latest\libraries\lodepng;.;..\..\..\include;..\..\..\components\libc\compilers\armlibc;..\..\..\components\libc\compilers\common;..\..\..\components\libc\compilers\common\nogcc;..\libraries\STM32F4xx_HAL\STM32F4xx_HAL_Driver\Inc;..\libraries\STM32F4xx_HAL\CMSIS\Device\ST\STM32F4xx\Include;..\libraries\STM32F4xx_HAL\CMSIS\Include;..\..\..\examples\utest\testcases\kernel
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  scatter file: .\board\linker_scripts\link.sct
  group Applications
    applications/: lcd_init.c main.c
  group CPU
    ../../../libcpu/arm/common/: backtrace.c showmem.c div0.c
    ../../../libcpu/arm/cortex-m4/: cpuport.c context_rvds.S
  group DeviceDrivers
    ../../../components/drivers/misc/: pin.c
    ../../../components/drivers/mtd/: mtd_nor.c
    ../../../components/drivers/sdio/: mmc.c sd.c block_dev.c sdio.c mmcsd_core.c
    ../../../components/drivers/serial/: serial.c
    ../../../components/drivers/src/: waitqueue.c dataqueue.c ringblk_buf.c pipe.c workqueue.c ringbuffer.c completion.c
  group Drivers
    board/ports/: drv_otm8009a.c
    board/CubeMX_Config/Src/: stm32f4xx_hal_msp.c
    board/: board.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/arm/: startup_stm32f469xx.s
    ../libraries/HAL_Drivers/: drv_sdram.c drv_gpio.c drv_usart.c drv_common.c drv_lcd_mipi.c
  group Filesystem
    ../../../components/dfs/src/: dfs_fs.c dfs.c dfs_file.c
    ../../../components/dfs/filesystems/devfs/: devfs.c
    ../../../components/dfs/filesystems/elmfat/: dfs_elm.c ff.c ffunicode.c
  group Finsh
    ../../../components/finsh/: shell.c msh.c msh_file.c cmd.c
  group gui_demo
    packages/gui_engine-latest/example/: gui_demo.c resources.c
  group GuiEngine
    packages/gui_engine-latest/src/: font_hz_file.c rtgui_system.c asc12font.c hz12font.c topwin.c asc16font.c dc_hw.c matrix.c rtgui_driver.c container.c server.c dc_rotozoom.c image_bmp.c rtgui_app.c image_jpg.c font.c image_png.c color.c filerw.c hz16font.c dc_buffer.c font_hz_bmp.c title.c window.c font_freetype.c image_container.c font_fnt.c blit.c font_bmp.c image_xpm.c mouse.c image.c dc_blend.c dc_trans.c rtgui_object.c widget.c dc_client.c dc.c box.c image_hdc.c region.c gb2312.c
    packages/gui_engine-latest/libraries/lodepng/: lodepng.c
  group Kernel
    ../../../src/: kservice.c timer.c irq.c mempool.c scheduler.c memheap.c ipc.c thread.c device.c object.c components.c clock.c idle.c
  group libc
    ../../../components/libc/compilers/armlibc/: syscalls.c libc.c mem_std.c stdio.c
    ../../../components/libc/compilers/common/: stdlib.c time.c
  group Libraries
    ../libraries/STM32F4xx_HAL/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal_uart.c stm32f4xx_hal_rcc_ex.c stm32f4xx_ll_dma2d.c stm32f4xx_hal_sd.c stm32f4xx_hal_nor.c stm32f4xx_hal_crc.c stm32f4xx_hal_cryp_ex.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_dma.c stm32f4xx_hal_usart.c stm32f4xx_hal_sdram.c stm32f4xx_hal_pwr.c stm32f4xx_hal_dma2d.c stm32f4xx_hal_rcc.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_gpio.c stm32f4xx_hal_rng.c stm32f4xx_hal_cortex.c stm32f4xx_hal_cryp.c stm32f4xx_ll_fsmc.c stm32f4xx_hal_ltdc.c stm32f4xx_hal.c stm32f4xx_hal_dsi.c stm32f4xx_hal_cec.c stm32f4xx_ll_sdmmc.c stm32f4xx_hal_ltdc_ex.c stm32f4xx_ll_fmc.c
    ../libraries/STM32F4xx_HAL/CMSIS/Device/ST/STM32F4xx/Source/Templates/: system_stm32f4xx.c
  group POSIX
    ../../../components/libc/posix/src/: select.c unistd.c poll.c delay.c
